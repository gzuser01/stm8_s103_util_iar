# IAR project s103_util.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; STM8S_StdPeriph_Driver\inc; C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.0 Evaluation\stm8\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: s103_util.hex
  ILINK.IlinkOutputFile: s103_util.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_uart1.c
  group user
    ./: ds1302.c ds1302.h main.c stm8s_conf.h stm8s_it.c stm8s_it.h uart1.c uart1.h
    STM8S_StdPeriph_Driver/src/: stm8s_gpio.c
    STM8S_StdPeriph_Driver/inc/: stm8s_gpio.h
